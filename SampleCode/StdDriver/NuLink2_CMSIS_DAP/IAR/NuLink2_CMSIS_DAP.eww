<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\NuLink2_CMSIS_DAP.ewp</path>
  </project>
  <batchBuild/>
</workspace>


