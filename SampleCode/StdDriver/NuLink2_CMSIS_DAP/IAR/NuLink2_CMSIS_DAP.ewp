# IAR project NuLink2_CMSIS_DAP.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\Library\Device\Nuvoton\M480\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc; $PROJ_DIR$..\..
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: NuLink2_CMSIS_DAP.bin
  ILINK.IlinkOutputFile: NuLink2_CMSIS_DAP.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/IAR/: startup_M480.s
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group DAP
    ../DAP/: DAP.c JTAG_DP.c SW_DP.c SWO.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c hsusbd.c retarget.c sys.c
  group User
    ../: DAP_config.h IO_Config.h descriptors.c hid_transfer.c main.c
  group Volatge
    ../Voltage/: Voltage.a Voltage.h
