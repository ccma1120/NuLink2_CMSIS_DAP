# IAR project Voltage.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Library\CMSIS\Include; ..\..\..\Library\Device\Nuvoton\M480\Include; ..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Voltage.bin
  ILINK.IlinkOutputFile: Voltage.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M480/Source/IAR/: startup_M480.s
    ../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../: EasyScale.cpp EasyScale.h Voltage.cpp Voltage.h Voltage_IO.h
